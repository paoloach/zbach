<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\zSmartSocket.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
       <member>
        <project>zSmartSocket</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


