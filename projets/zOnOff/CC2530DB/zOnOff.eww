<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\zOnOff.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
       <member>
        <project>zOnOff</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


