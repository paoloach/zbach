<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\zLightController.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
       <member>
        <project>zLightController</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


