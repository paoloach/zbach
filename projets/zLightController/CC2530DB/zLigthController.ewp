# IAR project zLigthController.ewp, settings and files
configuration RouterEB (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: HAL_LED=1; OSC32K_CRYSTAL_INSTALLED=FALSE; HAL_KEY=FALSE; HAL_BOARD_CC2530EB_REV17; SECURE=0; TC_LINKKEY_JOIN; NV_INIT; xNV_RESTORE; POWER_SAVING; NWK_AUTO_POLL; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_REPORT; zZCL_EZMODE; xZCL_BASIC; xZCL_IDENTIFY; xZCL_ON_OFF; xZCL_SCENES; xZCL_GROUPS; xxZCL_LEVEL_CTRL; xZCL_DIAGNOSTIC; FEATURE_SYSTEM_STATS
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\..\..\Components\ha; ..\..\..\Components\zmain; ..\..\..\Components\hal\include; ..\..\..\Components\hal\target\CC2530EB; ..\..\..\Components\mac\include; ..\..\..\Components\mac\high_level; ..\..\..\Components\mac\low_level\srf04; ..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\Components\mt; ..\..\..\Components\osal\include; ..\..\..\Components\services\saddr; ..\..\..\Components\services\sdata; ..\..\..\Components\stack\af; ..\..\..\Components\stack\nwk; ..\..\..\Components\stack\sapi; ..\..\..\Components\stack\sec; ..\..\..\Components\stack\sys; ..\..\..\Components\stack\zcl; ..\..\..\Components\stack\zdo; ..\..\..\Components\zmac; ..\..\..\Components\zmac\f8w
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\..\Tools\f8w2530.xcl
configuration EndDeviceEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\..\..; ..\..\..\clusters; ..\..\..\Components\external; ..\..\..\Components\ha; ..\..\..\Components\zmain; ..\..\..\Components\hal\include; ..\..\..\Components\hal\target\CC2530EB; ..\..\..\Components\mac\include; ..\..\..\Components\mac\high_level; ..\..\..\Components\mac\low_level\srf04; ..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\Components\mt; ..\..\..\Components\osal\include; ..\..\..\Components\services\saddr; ..\..\..\Components\services\sdata; ..\..\..\Components\stack\af; ..\..\..\Components\stack\nwk; ..\..\..\Components\stack\sapi; ..\..\..\Components\stack\sec; ..\..\..\Components\stack\sys; ..\..\..\Components\stack\zcl; ..\..\..\Components\stack\zdo; ..\..\..\Components\zmac; ..\..\..\Components\zmac\f8w
  ICC8051.CCOptLevel: 0
configuration EndDevicePA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: HAL_LED=1; DHT12=1; SECURE=1; OSC32K_CRYSTAL_INSTALLED=FALSE; HAL_KEY=FALSE; HAL_BOARD_CC2530EB_REV17; HAL_PA_LNA_CC2592; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xPOWER_SAVING; NWK_AUTO_POLL; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_REPORT; zZCL_EZMODE; xZCL_BASIC; xZCL_IDENTIFY; xZCL_ON_OFF; xZCL_SCENES; xZCL_GROUPS; xxZCL_LEVEL_CTRL; xZCL_DIAGNOSTIC; xFEATURE_SYSTEM_STATS
  ICC8051.CCIncludePath2: ..\..\..\clusters; ..\Source; ..\..\..\; ..\..\..\Components\external; ..\..\..\Components\ha; ..\..\..\Components\zmain; ..\..\..\Components\hal\include; ..\..\..\Components\hal\target\CC2530EB; ..\..\..\Components\mac\include; ..\..\..\Components\mac\high_level; ..\..\..\Components\mac\low_level\srf04; ..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\Components\mt; ..\..\..\Components\osal\include; ..\..\..\Components\services\saddr; ..\..\..\Components\services\sdata; ..\..\..\Components\stack\af; ..\..\..\Components\stack\nwk; ..\..\..\Components\stack\sapi; ..\..\..\Components\stack\sec; ..\..\..\Components\stack\sys; ..\..\..\Components\stack\zcl; ..\..\..\Components\stack\zdo; ..\..\..\Components\zmac; ..\..\..\Components\zmac\f8w
  ICC8051.CCOptLevel: 0
configuration RouterPA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: ..\..\..\clusters; ..\Source; ..\..\..\Components\external; ..\..\..\; ..\..\..\Components\ha; ..\..\..\Components\zmain; ..\..\..\Components\hal\include; ..\..\..\Components\hal\target\CC2530EB; ..\..\..\Components\mac\include; ..\..\..\Components\mac\high_level; ..\..\..\Components\mac\low_level\srf04; ..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\Components\mt; ..\..\..\Components\osal\include; ..\..\..\Components\services\saddr; ..\..\..\Components\services\sdata; ..\..\..\Components\stack\af; ..\..\..\Components\stack\nwk; ..\..\..\Components\stack\sapi; ..\..\..\Components\stack\sec; ..\..\..\Components\stack\sys; ..\..\..\Components\stack\zcl; ..\..\..\Components\stack\zdo; ..\..\..\Components\zmac; ..\..\..\Components\zmac\f8w
  ICC8051.CCOptLevel: 0
configuration EndDevice_DH112 (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 0
configuration EndDevice-DS18B20 (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptStrategy: 0
  group (top)
    EndDeviceEB/Exe/: TemperatureSensor.d51
  group App
    ../Source/: ledBlink.c OSAL_TemperatureSensor.c TemperatureSensor.c TemperatureSensor.h TemperatureSensor_data.c
  group App/clusters
    ../../../clusters/: ClusterBasic.c ClusterHumidityRelativeMeasurement.c ClusterIdentify.c ClusterPower.c ClusterTemperatureMeasurement.c report.h
    ../Source/clusters/: ClusterData.c
  group App/clusters/includes
    ../../../clusters/: ClusterBasic.h ClusterHumidityRelativeMeasurement.h ClusterIdentify.h ClusterOSALEvents.h ClusterPower.h ClusterTemperatureMeasurement.h
  group external
    ../../../Components/external/: dht112.h dht112_I2C.c dht112_SingleWire.c DS18B20.c DS18B20.h EventManager.c regs.h
  group HAL/Common
    ../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2530EB/Config
    ../../../Components/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../../../Components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530EB/Includes
    ../../../Components/hal/target/CC2530EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/ZLIGHT/Config
    ../../../../../Components/hal/target/CC2530PMP4712/: hal_board_cfg.h
  group HAL/Target/ZLIGHT/Drivers
    ../../../../../Components/hal/target/CC2530PMP4712/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/ZLIGHT/Include
    ../../../../../Components/hal/target/CC2530PMP4712/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group libSource
    ../../../libSources/: network.c
  group MAC/High Level
    ../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    ../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group NWK
    ../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../../../Components/stack/sys/: ZDiags.c ZDiags.h ZGlobals.c ZGlobals.h
  group OSAL
    ../../../Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c OSAL_Timers2.c
    ../../../Components/osal/mcu/cc2530/: OSAL_Math.s51 OSAL_Nv.c
  group Profile
    ../../../Components/stack/af/: AF.c AF.h
    ../../../Components/osal/include/: osal_task.h
    ../../../Components/stack/zcl/: zcl.c zcl.h zcl_diagnostic.c zcl_diagnostic.h zcl_ezmode.c zcl_ezmode.h zcl_general.c zcl_general.h zclReadAttributeFn.c zclReadAttributeFn.h zclWriteAttributeFn.c zclWriteAttributeFn.h
    ../../../Components/ha/: zcl_ha.c zcl_ha.h
  group Security
    ../../../Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../Configuration/: f8wConfig.cfg
    ../../../Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../../Tools/: f8w2530.xcl
    ../Configuration/: f8wEndev.cfg f8wZCL.cfg params-DHT12.cfg params-DS18B20.cfg pins.cfg
  group ZDO
    ../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../../Components/zmain/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
